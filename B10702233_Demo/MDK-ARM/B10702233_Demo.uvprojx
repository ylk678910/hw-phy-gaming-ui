# Keil uVision project B10702233_Demo.uvprojx, settings and files
target B10702233_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: B10702233_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\UserDefined;..\..\ObjectLibrary\Include;C:\Users\ylk67\AppData\Local\Arm\Packs\Keil\STM32F7xx_DFP\2.13.0\Drivers\BSP\Components\ft5336;C:\Users\ylk67\AppData\Local\Arm\Packs\Keil\STM32F7xx_DFP\2.13.0\Drivers\BSP\STM32746G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group BSP
    C:/Users/ylk67/AppData/Local/Arm/Packs/Keil/STM32F7xx_DFP/2.13.0/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    C:/Users/ylk67/AppData/Local/Arm/Packs/Keil/STM32F7xx_DFP/2.13.0/Drivers/BSP/Components/ft5336/: ft5336.c
  group Object
    ../../ObjectLibrary/Source/: Object.c ObjectGroup.c ObjectTime.c PyObj.c
  group UserCode
    ../UserDefined/: ObjUserFunc.c
software components: CMSIS:CORE 4.3.0
